Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_90.116_CAIXA_DE_EMBUTIR_MÓDULO_DE_COMANDO.IFC
Time: 2022-05-18T17:16:22
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DRACO_90.116_CAIXA_DE_EMBUTIR_MÓDULO_DE_COMANDO
In: Default Storey
Material: AISI 1020
