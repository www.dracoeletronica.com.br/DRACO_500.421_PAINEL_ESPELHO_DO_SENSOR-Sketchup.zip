Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_90.550_TORNEIRA_SENSOR_PAREDE_CLEAN.IFC
Time: 2022-05-18T14:13:44
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0
