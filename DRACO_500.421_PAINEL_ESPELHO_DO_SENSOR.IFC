Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_500.421_PAINEL_ESPELHO_DO_SENSOR.IFC
Time: 2022-05-18T15:17:42
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBeam: DRACO_500.421_PAINEL_ESPELHO_DO_SENSOR
In: Default Storey
Material: AISI 1020
